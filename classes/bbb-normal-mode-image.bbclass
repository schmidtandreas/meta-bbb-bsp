SUMMARY = "Resuable class representing normal mode image for BBB"

LICENSE = "MIT"

inherit bbb-common-image

IMAGE_FSTYPES = "ext4"
