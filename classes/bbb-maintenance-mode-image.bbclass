SUMMARY = "Reusable class representing maintenance mode image for BBB"

LICENSE = "MIT"

inherit bbb-common-image

IMAGE_FSTYPES = "squashfs"
