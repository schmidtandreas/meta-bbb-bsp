SUMMARY = "A full system image for BBB."

LICENSE = "MIT"

inherit bbb-full-system-image
