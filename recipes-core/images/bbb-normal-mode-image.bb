SUMMARY = "A normal mode image for BBB."

LICENSE = "MIT"

inherit bbb-normal-mode-image
