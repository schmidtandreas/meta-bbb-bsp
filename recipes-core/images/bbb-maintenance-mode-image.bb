SUMMARY = "A maintenance mode image for BBB."

LICENSE = "MIT"

inherit bbb-maintenance-mode-image
